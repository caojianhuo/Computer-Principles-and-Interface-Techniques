# Keil uVision project armExperiment1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32H745ZITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: armExperiment1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Source Group 1
    ./: problem5.s
